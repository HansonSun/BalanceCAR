# Keil uVision project TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\HARDWARE;..\App;..\SYS\adc;..\SYS\delay;..\SYS\gpio;..\SYS\misc;..\SYS\pwm;..\SYS\sys;..\SYS\timer;..\SYS\uart;..\UpperComputer;..\Interupt;..\SYS;..\SYS\input_capture;..\HARDWARE\encoder;..\SYS\exti
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c
  group SYS
    ../SYS/adc/: adc.c
    ../SYS/delay/: delay.c
    ../SYS/gpio/: gpio.c
    ../SYS/misc/: misc.c
    ../SYS/pwm/: pwm.c
    ../SYS/timer/: timer.c
    ../SYS/uart/: usart.c
    ../SYS/: sys.c
    ../SYS/input_capture/: input_capture.c
    ../SYS/exti/: exti.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/encoder/: encoder.c
  group App
    ../App/: daolibai.c
  group UpperComputer
    ../UpperComputer/: DataScope_DP.C
  group Interupt
    ../Interupt/: EXTI_IRQ.c TIM1_IRQ.c TIM2_IRQ.c TIM3_IRQ.c TIM4_IRQ.c TIM5_IRQ.c USART1_IRQ.c USART2_IRQ.c USART3_IRQ.c
